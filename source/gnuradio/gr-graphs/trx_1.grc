options:
  parameters:
    author: emi
    generate_options: qt_gui
    id: trx
    output_language: python
    qt_qss_theme: /home/emi/.local/share/gnuradio/3.8.0/share/gnuradio/themes/dark.qss
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1.161e6
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '3'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 255/6
    type: float
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: '4'
    differential: 'True'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: '2'
    timing_bw: 6.28/100.0
  states: {}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '4'
    differential: 'True'
    excess_bw: '0.35'
    log: 'True'
    mod_code: '"gray"'
    samples_per_symbol: '2'
    verbose: 'True'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymax: '256'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: '1'
    type: float
    update_time: '0.1'
    ymax: '256'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: '1'
    type: float
  states: {}
- name: vlc_board_interface_b_0
  id: vlc_board_interface_b
  parameters:
    address: 192.168.1.23
    block_size: '256'
    cmd_port: '7777'
    data_port: '6666'
  states: {}
- name: vlc_nic_interface_b_0
  id: vlc_nic_interface_b
  parameters:
    address: /tmp/vlc_gr_server_1
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_float_0, '1', blocks_add_xx_0, '1']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_1, '1']
- [blocks_float_to_uchar_0, '0', vlc_board_interface_b_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_psk_demod_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_psk_mod_0, '0', blocks_complex_to_float_0, '0']
- [digital_psk_mod_0, '0', blocks_tag_debug_0, '0']
- [digital_psk_mod_0, '0', digital_psk_demod_0, '0']
- [digital_psk_mod_0, '0', qtgui_const_sink_x_0, '0']
- [vlc_board_interface_b_0, '0', blocks_uchar_to_float_0, '0']
- [vlc_board_interface_b_0, vlc_board_int_msg_out, vlc_nic_interface_b_0, msg_in]
- [vlc_nic_interface_b_0, '0', digital_psk_mod_0, '0']
- [vlc_nic_interface_b_0, msg_out, vlc_board_interface_b_0, vlc_board_int_msg_in]

metadata:
  file_format: 1

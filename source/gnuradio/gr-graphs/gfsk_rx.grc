options:
  parameters:
    author: JoJo
    generate_options: qt_gui
    id: test_rx
    output_language: python
    title: test_rx
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1.161e6
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '4096'
    srate: samp_rate
    type: float
  states: {}
- name: vlc_vlc_device_source_b_0
  id: vlc_vlc_device_source_b
  parameters:
    address: 192.168.1.23
    block_size: '256'
    cmd_port: '7777'
    data_port: '6666'
  states: {}

connections:
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [vlc_vlc_device_source_b_0, '0', blocks_uchar_to_float_0, '0']

metadata:
  file_format: 1

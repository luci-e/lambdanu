options:
  parameters:
    author: emi
    generate_options: qt_gui
    id: sine
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: pi
  id: variable
  parameters:
    value: '3.1415'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_2
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 255/6
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '32'
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: '32'
    sensitivity: 2*pi
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymax: '256'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ymax: '256'
  states: {}
- name: vlc_board_interface_b_0
  id: vlc_board_interface_b
  parameters:
    address: 192.168.1.23
    block_size: '256'
    cmd_port: '7777'
    data_port: '6666'
  states: {}
- name: vlc_nic_interface_b_0
  id: vlc_nic_interface_b
  parameters:
    address: /tmp/vlc_gr_server
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_add_const_vxx_2, '0', blocks_repeat_0, '0']
- [blocks_float_to_uchar_0, '0', vlc_board_interface_b_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_repeat_0, '0', blocks_vco_f_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_1, '0', blocks_add_const_vxx_2, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_1, '0']
- [blocks_vco_f_0, '0', blocks_add_const_vxx_0, '0']
- [vlc_board_interface_b_0, '0', blocks_uchar_to_float_0, '0']
- [vlc_board_interface_b_0, vlc_board_int_msg_out, vlc_nic_interface_b_0, msg_in]
- [vlc_nic_interface_b_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [vlc_nic_interface_b_0, msg_out, vlc_board_interface_b_0, vlc_board_int_msg_in]

metadata:
  file_format: 1

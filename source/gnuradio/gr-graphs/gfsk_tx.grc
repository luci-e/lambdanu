options:
  parameters:
    author: JoJo
    generate_options: no_gui
    id: gfsk_tx
    output_language: python
    run_options: run
    title: gfsk_tx
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: transmission_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '255'
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate/transmission_rate*32)
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: parameter_0
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: vlc_vlc_board_interface_b_0
  id: vlc_vlc_board_interface_b
  parameters:
    address: 192.168.1.24
    block_size: '256'
    cmd_port: '7777'
    data_port: '6666'
  states: {}
- name: vlc_vlc_packet_source_b_0
  id: vlc_vlc_packet_source_b
  parameters:
    address: vlc_gr_server
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_uchar_0, '0', vlc_vlc_board_interface_b_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_repeat_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [vlc_vlc_board_interface_b_0, vlc_board_int_msg_out, vlc_vlc_packet_source_b_0, vlc_pkt_src_msg_in]
- [vlc_vlc_packet_source_b_0, '0', blocks_unpack_k_bits_bb_0, '0']

metadata:
  file_format: 1
